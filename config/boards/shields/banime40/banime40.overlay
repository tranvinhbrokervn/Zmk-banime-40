/*
 * Copyright (c) 2024 The ZMK Contributors
 *
 * SPDX-License-Identifier: MIT
 */

#include "banime40.dtsi"
// Liên kết các node encoder và nút nhấn vào shield
&encoder0 {};
&encoder_button {};
